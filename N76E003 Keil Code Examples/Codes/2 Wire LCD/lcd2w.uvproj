# Keil uVision project lcd2w.uvproj, settings and files
target 2 Wire LCD (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: lcd2w +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\2 Wire LCD
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group My Libraries
    ../../My_Libraries/2 Wire LCD/: LCD_2_Wire.c PCF8574.c SW_I2C.c
  group Startup
    ../../Startup/: STARTUP.A51
