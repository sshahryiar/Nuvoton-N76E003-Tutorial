# Keil uVision project pwms.uvproj, settings and files
target PWM_Simple (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: pwms +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\Software Delay
  asm include: ..\..\Include
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP.A51
  group My_Libraries
    ../../My_Libraries/Software Delay/: soft_delay.c
