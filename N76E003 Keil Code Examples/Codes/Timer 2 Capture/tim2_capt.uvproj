# Keil uVision project tim2_capt.uvproj, settings and files
target Timer 2 Capture Example (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: tim2_capt +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\3 Wire LCD
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group My Libraries
    ../../My_Libraries/3 Wire LCD/: LCD_3_Wire.c
  group Startup
    ../../Startup/: STARTUP.A51
