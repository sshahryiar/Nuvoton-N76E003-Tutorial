# Keil uVision project spi.uvproj, settings and files
target SPI_Example (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: spi +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\MAX6675;..\..\My_Libraries\MAX7219;..\..\My_Libraries\Software Delay
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group My Libraries
    ../../My_Libraries/Software Delay/: soft_delay.c
    ../../My_Libraries/MAX7219/: MAX72xx.c
    ../../My_Libraries/MAX6675/: MAX6675.c
  group Startup
    ../../Startup/: STARTUP.A51
