# Keil uVision project i2c.uvproj, settings and files
target I2C Example (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: i2c +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\3 Wire LCD (Software Delay);..\..\My_Libraries\I2C;..\..\My_Libraries\DS1307;..\..\My_Libraries\Software Delay
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group My Libraries
    ../../My_Libraries/3 Wire LCD (Software Delay)/: LCD_3_Wire.c
    ../../My_Libraries/DS1307/: DS1307.c
    ../../My_Libraries/I2C/: I2C.c
    ../../My_Libraries/Software Delay/: soft_delay.c
  group Startup
    ../../Startup/: STARTUP.A51
