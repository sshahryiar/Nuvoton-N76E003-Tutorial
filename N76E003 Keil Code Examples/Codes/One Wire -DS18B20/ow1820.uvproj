# Keil uVision project ow1820.uvproj, settings and files
target One Wire Communication - DS18B20 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ow1820 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\Software Delay;..\..\My_Libraries\DS18B20;..\..\My_Libraries\3 Wire LCD (Software Delay)
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group My Libraries
    ../../My_Libraries/Software Delay/: soft_delay.c
    ../../My_Libraries/DS18B20/: DS18B20.c one_wire.c
    ../../My_Libraries/3 Wire LCD (Software Delay)/: LCD_3_Wire.c
  group Startup
    ../../Startup/: STARTUP.A51
