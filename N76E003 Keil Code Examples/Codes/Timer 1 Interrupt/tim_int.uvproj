# Keil uVision project tim_int.uvproj, settings and files
target Timer 1 Mode 0 Interrupt (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: tim_int
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include;..\..\My_Libraries\3 Wire LCD
  group Source
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group Startup
    ../../Startup/: STARTUP.A51
  group My Libraries
    ../../My_Libraries/3 Wire LCD/: LCD_3_Wire.c
