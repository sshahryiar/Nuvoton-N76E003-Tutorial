<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\twi_lcd.ewp</path>
    </project>
    <batchBuild />
</workspace>
