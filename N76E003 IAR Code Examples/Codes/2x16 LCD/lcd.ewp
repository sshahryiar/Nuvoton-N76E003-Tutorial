# IAR project lcd.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: FOSC160000=1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Users\SShahryiar\Desktop\N76E003 Tutorial\N76E003 IAR Code Examples\Include; C:\Users\SShahryiar\Desktop\N76E003 Tutorial\N76E003 IAR Code Examples\My_Libraries\LCD
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  group (top)
    ../../Common/: Common.c Delay.c
    ../../My_Libraries/LCD/: LCD.c
    ./: main.c
