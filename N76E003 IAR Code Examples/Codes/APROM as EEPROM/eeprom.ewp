# IAR project eeprom.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.CCDefines: FOSC_160000=1
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Users\sshah\Desktop\N76E003 Tutorial\N76E003 IAR Code Examples\Include; C:\Users\sshah\Desktop\N76E003 Tutorial\N76E003 IAR Code Examples\My_Libraries\Software Delay; C:\Users\sshah\Desktop\N76E003 Tutorial\N76E003 IAR Code Examples\My_Libraries\Flash; C:\Users\sshah\Desktop\N76E003 Tutorial\N76E003 IAR Code Examples\My_Libraries\2 Wire LCD  (Software Delay)
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\NuvoTon\lnk51ew_N76E003.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ./: main.c
  group Common
    ../../Common/: Common.c Delay.c
  group My Libraries
    ../../My_Libraries/Flash/: Flash.c
    ../../My_Libraries/2 Wire LCD  (Software Delay)/: LCD_2_Wire.c PCF8574.c SW_I2C.c
    ../../My_Libraries/Software Delay/: soft_delay.c
